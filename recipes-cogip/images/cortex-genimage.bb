DESCRIPTION = "COGIP Cortex genimage image"

require cogip-common-genimage.inc

GENIMAGE_ROOTFS_IMAGE = "cortex-image"
