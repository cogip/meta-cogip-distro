DESCRIPTION = "COGIP Cortex debug genimage image"

require cortex-genimage.bb

GENIMAGE_ROOTFS_IMAGE = "cortex-dbg-image"
