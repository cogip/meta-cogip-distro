DESCRIPTION = "COGIP Cortex debug image"

require cortex-image.bb

#IMAGE_INSTALL += " \
#    kmscube \
#"
